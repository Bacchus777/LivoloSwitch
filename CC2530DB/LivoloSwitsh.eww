<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LivoloSwitsh.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>ALL</name>
            <member>
                <project>LivoloSwitsh</project>
                <configuration>LivoloSwitsh_EndDevice</configuration>
            </member>
            <member>
                <project>LivoloSwitsh</project>
                <configuration>LivoloSwitsh_Router</configuration>
            </member>
            <member>
                <project>LivoloSwitsh</project>
                <configuration>LivoloSwitsh_Router_CC2592</configuration>
            </member>
            <member>
                <project>LivoloSwitsh</project>
                <configuration>LivoloSwitsh_EndDevice_CC2592</configuration>
            </member>
            <member>
                <project>LivoloSwitsh</project>
                <configuration>LivoloSwitsh_EndDevice_CC2591</configuration>
            </member>
            <member>
                <project>LivoloSwitsh</project>
                <configuration>LivoloSwitsh_Router_CC2591</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
